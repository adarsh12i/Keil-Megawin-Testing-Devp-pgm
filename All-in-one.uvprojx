# Keil uVision project All-in-one.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MG32F02U128 Megawin
  pack: Megawin.CM0_DFP.2.1.1
  cpu: IRAM(0x20000000,0x3800) IRAM2(0x20003800,0x800) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Standard_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\RTE\ChipInit_Wizard;.\RTE\aa;.\RTE\_Target_1
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x3800
  memory RVCT10: RAM 0x20003800 size 0x800
  group Source Group 1
    ./: Sample_main_wizard.c
software components: CMSIS Driver:Flash:Custom 1.0.0, CMSIS Driver:SPI:Custom 1.0.0, CMSIS Driver:USART:Custom 1.0.0, CMSIS Driver:USB Host:Custom 1.0.0, CMSIS:CORE 5.5.0, ChipInit_Wizard:ADC 1.0.0, ChipInit_Wizard:APB 1.0.0, ChipInit_Wizard:APX_CCL 1.0.0, ChipInit_Wizard:CMP 1.0.0, ChipInit_Wizard:CSC 1.0.4, ChipInit_Wizard:DAC 1.0.0, ChipInit_Wizard:EMB 1.0.2, ChipInit_Wizard:EXIC 1.0.2, ChipInit_Wizard:GPIO 1.0.0, ChipInit_Wizard:GPL 1.0.1, ChipInit_Wizard:IRQ handler 1.0.5, ChipInit_Wizard:MEM 1.0.1, ChipInit_Wizard:PW 1.0.3, ChipInit_Wizard:RST 1.0.3, ChipInit_Wizard:RTC 1.0.0, ChipInit_Wizard:Timer 1.0.0, ChipInit_Wizard:URT 1.0.1, Device:Startup 1.0.4, Driver:Driver-All 1.0.1, IRQ_Handler:Enable EXINT0 NVIC 1.0.0
